# Keil uVision project F7.uvprojx, settings and files
target F7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: F7
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;                                                     ../Drivers/STM32F7xx_HAL_Driver/Inc;                                                     ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                                     ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                                     ../Drivers/CMSIS/Include;                                                     ..\Drivers\BSP\STM32746G-Discovery;                                                     ..\Drivers\BSP\Components\rk043fn48h;                                                     ..\Drivers\BSP\Components\Common;                                                     ..\Utilities\CPU;                                                     ..\Utilities\Fonts;                                                     ..\Utilities\Log;                                                    ../Middlewares/Third_Party/FatFs/src/drivers;                                                    ../Middlewares/Third_Party/FatFs/src;          ../Middlewares/Third_Party/LwIP/src/include;          ../Middlewares/Third_Party/LwIP/system;          ../Middlewares/Third_Party/LwIP/src/include/lwip;          ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;          ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;          ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;          ../Middlewares/Third_Party/LwIP/src/include/netif;          ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;          ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;          ../Middlewares/Third_Party/LwIP/src/include/posix;          ../Middlewares/Third_Party/LwIP/src/include/posix/sys;          ../Middlewares/Third_Party/LwIP/system/arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0xd0000000 size 0x800000
  scatter file: F7\F7.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32746G-Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_qspi.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_qspi.c stm32f7xx_hal_eth.c stm32f7xx_hal_uart.c stm32f7xx_hal_spi.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c
  group Application/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c main.c bsp_driver_sd.c fatfs.c sdmmc.c dma2d.c ltdc.c fmc.c i2c.c sai.c gpio.c wm8994.c tim.c ft5336.c quadspi.c usart.c lwip.c ethernetif.c net.c spi.c adc.c dma.c
    ../Inc/: audio.h audio_handler.h guifunc.h guistatic.h logo.h pads_color.h service_mode.h skins.h timer_handler.h encoder_handler.h key_handler.h preset_list.h utility.h dac.h edit_preset_gui.h edit_list_gui.h edit_fl_list.h edit_utility_gui.h delete_dialog_gui.h global_variables.h sync_mode_upd.h fat_process.h edit_pad_display.h edit_preset_display.h keyboard.h waveformanalyzer.h browser.h slide_fl_pads.h move_preset.h
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c mem.c tcp.c tcp_out.c pbuf.c timeouts.c ip.c init.c inet_chksum.c netif.c sys.c def.c raw.c stats.c udp.c memp.c dns.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: mppe.c multilink.c pppos.c ipv6cp.c chap-new.c lcp.c fsm.c pppoe.c ppp.c eui64.c upap.c chap_ms.c ecp.c utils.c eap.c ipcp.c chap-md5.c pppol2tp.c auth.c ccp.c magic.c vj.c pppapi.c pppcrypt.c demand.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c netifapi.c tcpip.c err.c netdb.c api_lib.c netbuf.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c icmp.c igmp.c ip4_frag.c etharp.c autoip.c ip4_addr.c ip4.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c nd6.c ip6.c ethip6.c mld6.c icmp6.c inet6.c dhcp6.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: des.c md4.c md5.c arc4.c sha1.c
software components: CMSIS:CORE 4.1.0
